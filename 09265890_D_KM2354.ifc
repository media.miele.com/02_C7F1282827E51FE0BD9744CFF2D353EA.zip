Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: b804b341-cede-42bb-a43c-32c320a0eafa, NumberOfSaves: 1]
File name: 0001
Time: 2026-01-14T06:49:45+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 09265890_D_KM2354:26235450_D_9265890_KM2354, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 888 mm; Height: 75 mm; Depth: 508 mm
Classification: E1090320 Uniformat (Uniformat); Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, <Unnamed>, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Gas, z_Miele_Connection_Electric, z_Miele_Design_Cast
Pset_BuildingElementProxyCommon - Reference: 26235450_D_9265890_KM2354; sets with these values: 2

# IfcDistributionPort, Port_355108_1
Description: Flow; FlowDirection: SOURCEANDSINK
